# Keil uVision project 51lib.uvproj, settings and files
target 51lib (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 51lib (library)
  AfterMake: E:\C.Code\git_project\51lib\51lib_release.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\core\inc
  group Source Group
    ./: STARTUP.A51
    ./core/src/: Calculation.c delay.c delay_nop.c ExternalInterrupt0.c Interrupt.c Serial.c SerialBase.c T2_Delay.c TimeCounter0.c Timer2.c Timer2_PWM.c
  group Include Group
    ./core/inc/: Calculation.h delay.h delay_nop.h ExternalInterrupt0.h Global.h Interrupt.h mutex.h Serial.h SerialBase.h T2_delay.h TimeCounter0.h Timer.h Timer2.h Timer2_PWM.h
