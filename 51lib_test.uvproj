# Keil uVision project 51lib_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 51lib_test
  BeforeMake: E:\C.Code\git_project\51lib\51lib.BAT
  c flags: Optimize=8 SizeSpeed=1
  c include: .\51lib_release\inc
  group Source Group 1
    ./: STARTUP.A51 test.c
    ./51lib_release/: 51lib.LIB
  group Include Group
    ./51lib_release/inc/: 51lib.h
